options:
  parameters:
    generate_options: qt_gui
    id: SparSDR_reconstruct_100MHz
    output_language: python
    title: SparSDR reconstruction of 100MHz
  states: {}

blocks:
- name: variable_sparsdr_reconstruct_0
  id: variable_sparsdr_reconstruct
  parameters:
    band_0_bins: '1024'
    band_0_frequency: '-25000000'
    band_10_bins: '2048'
    band_10_frequency: '0.0'
    band_11_bins: '2048'
    band_11_frequency: '0.0'
    band_12_bins: '2048'
    band_12_frequency: '0.0'
    band_13_bins: '2048'
    band_13_frequency: '0.0'
    band_14_bins: '2048'
    band_14_frequency: '0.0'
    band_15_bins: '2048'
    band_15_frequency: '0.0'
    band_16_bins: '2048'
    band_16_frequency: '0.0'
    band_17_bins: '2048'
    band_17_frequency: '0.0'
    band_18_bins: '2048'
    band_18_frequency: '0.0'
    band_19_bins: '2048'
    band_19_frequency: '0.0'
    band_1_bins: '1024'
    band_1_frequency: '25000000'
    band_20_bins: '2048'
    band_20_frequency: '0.0'
    band_21_bins: '2048'
    band_21_frequency: '0.0'
    band_22_bins: '2048'
    band_22_frequency: '0.0'
    band_23_bins: '2048'
    band_23_frequency: '0.0'
    band_24_bins: '2048'
    band_24_frequency: '0.0'
    band_25_bins: '2048'
    band_25_frequency: '0.0'
    band_26_bins: '2048'
    band_26_frequency: '0.0'
    band_27_bins: '2048'
    band_27_frequency: '0.0'
    band_28_bins: '2048'
    band_28_frequency: '0.0'
    band_29_bins: '2048'
    band_29_frequency: '0.0'
    band_2_bins: '2048'
    band_2_frequency: '0.0'
    band_30_bins: '2048'
    band_30_frequency: '0.0'
    band_31_bins: '2048'
    band_31_frequency: '0.0'
    band_3_bins: '2048'
    band_3_frequency: '0.0'
    band_4_bins: '2048'
    band_4_frequency: '0.0'
    band_5_bins: '2048'
    band_5_frequency: '0.0'
    band_6_bins: '2048'
    band_6_frequency: '0.0'
    band_7_bins: '2048'
    band_7_frequency: '0.0'
    band_8_bins: '2048'
    band_8_frequency: '0.0'
    band_9_bins: '2048'
    band_9_frequency: '0.0'
    band_count: '2'
    compressed_format: N210 v2
    compression_fft_size: '2048'
    reconstruct_path: sparsdr_reconstruct
    zero_gaps: 'False'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 50e6
    fc: 2.425e9
    fftsize: '1024'
    gui_hint: (0,0,1,1)
    int_max: '-20'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 50e6
    fc: 2.475e9
    fftsize: '1024'
    gui_hint: (0,1,1,1)
    int_max: '-20'
    type: complex
  states: {}
- name: sparsdr_compressing_usrp_source_0
  id: sparsdr_compressing_usrp_source
  parameters:
    antenna: RX2
    bin_spec: 0..8:1
    center_freq: '2500000000'
    device_addr: ''
    gain: '30'
    skip_config: 'False'
    threshold: '10000'
    threshold_file: ''
    threshold_source: Fixed threshold
  states: {}

connections:
- [sparsdr_compressing_usrp_source_0, '0', variable_sparsdr_reconstruct_0, '0']
- [variable_sparsdr_reconstruct_0, '0', qtgui_waterfall_sink_x_0, '0']
- [variable_sparsdr_reconstruct_0, '1', qtgui_waterfall_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: v3.10.5.1-1-gf972571a
